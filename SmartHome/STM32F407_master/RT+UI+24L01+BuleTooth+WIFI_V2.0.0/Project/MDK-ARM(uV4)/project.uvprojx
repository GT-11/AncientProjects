# Keil uVision project project.uvprojx, settings and files
target Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\emWin\Config;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c FreeRTOSConfig.h timertest.c Net_24L01.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c
  group BSP
    ../../User/bsp_stm32f4xx/: bsp.c
    ../../User/bsp_stm32f4xx/src/: bsp_uart.c bsp_printf.c bsp_i2c_gpio.c bsp_dwt.c 24l01.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_spi.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group FreeRTOS/Source
    ../../FreeRTOS/: timers.c croutine.c list.c queue.c tasks.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_2.c
  group LCD_Driver
    ../../User/bsp_stm32f4xx/src/: bsp_gt811.c bsp_tft_lcd.c bsp_touch.c LCD_RA8875.c bsp_ra8875_port.c
    ../../emWin/DisplayDriver/: GUIDRV_Template.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_FreeRTOS.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin526_CM4_OS_Keil.lib
  group GUIDEMO
    ../../emWin/emWinTask/: MainTask.c
    ../../GUI/: Air_A.c Air_B.c Air_C.c Light.c
  group GUI/TOUCH
    ../../emWin/GUI_X/: GUI_X_Touch.c GUI_X_Touch_Analog.c GUI_X_Touch_StoreState.c
