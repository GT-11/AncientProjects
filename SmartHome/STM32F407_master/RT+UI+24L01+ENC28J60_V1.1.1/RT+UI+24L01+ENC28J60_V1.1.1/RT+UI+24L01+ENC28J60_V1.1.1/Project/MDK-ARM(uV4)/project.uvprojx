# Keil uVision project project.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\emWin\Config;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\GUI;..\..\LWIP\lwip-1.4.1\src\include\lwip;..\..\LWIP\lwip-1.4.1\src\include;..\..\LWIP\lwip-1.4.1\arch;..\..\LWIP\lwip-1.4.1\lwip_comm;..\..\MALLOC;..\..\lLWIP\wip-1.4.1\src\include\netif;..\..\LWIP\lwip-1.4.1\src\include\ipv4;..\..\LWIP;..\..\LWIP\arch;..\..\LWIP\lwip_app\lwip_comm;..\..\LWIP\lwip_app\tcp_client_demo;..\..\LWIP\lwip_app\tcp_server_demo;..\..\LWIP\lwip_app\udp_demo;..\..\LWIP\lwip_app\web_server_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c FreeRTOSConfig.h timertest.c Net_24L01.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c
  group BSP
    ../../User/bsp_stm32f4xx/: bsp.c
    ../../User/bsp_stm32f4xx/src/: bsp_uart.c bsp_printf.c bsp_i2c_gpio.c bsp_dwt.c 24l01.c enc28j60.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_spi.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group FreeRTOS/Source
    ../../FreeRTOS/: timers.c croutine.c list.c queue.c tasks.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_2.c
  group LCD_Driver
    ../../User/bsp_stm32f4xx/src/: bsp_gt811.c bsp_tft_lcd.c bsp_touch.c LCD_RA8875.c bsp_ra8875_port.c
    ../../emWin/DisplayDriver/: GUIDRV_Template.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_FreeRTOS.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin526_CM4_OS_Keil.lib
  group GUIDEMO
    ../../emWin/emWinTask/: MainTask.c
    ../../GUI/: Air_A.c Air_B.c Air_C.c Light.c
  group GUI/TOUCH
    ../../emWin/GUI_X/: GUI_X_Touch.c GUI_X_Touch_Analog.c GUI_X_Touch_StoreState.c
  group LWIP/ETH
    ../../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP/Core
    ../../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group LWIP/Arch
    ../../LWIP/arch/: sys_arch.c
  group LWIP/API
    ../../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP/APP
    ../../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../../LWIP/lwip_app/tcp_client_demo/: tcp_client_demo.c
    ../../LWIP/lwip_app/tcp_server_demo/: tcp_server_demo.c
    ../../LWIP/lwip_app/udp_demo/: udp_demo.c
    ../../LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group LWIP/MALLOC
    ../../MALLOC/: malloc.c
