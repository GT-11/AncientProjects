# Keil uVision project project.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,__FPU_USED=1
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\emWin\Config;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\GUI;..\..\HARDWARE\ADC;..\..\HARDWARE\DAC;..\..\HARDWARE\DMA;..\..\HARDWARE\SRAM;..\..\HARDWARE\TIMER;..\..\DSP_LIB\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c FreeRTOSConfig.h timertest.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c
  group BSP
    ../../User/bsp_stm32f4xx/: bsp.c
    ../../User/bsp_stm32f4xx/src/: bsp_uart.c bsp_printf.c bsp_dwt.c
    ../../HARDWARE/ADC/: adc.c
    ../../HARDWARE/DAC/: dac.c
    ../../HARDWARE/DMA/: dma.c
    ../../HARDWARE/SRAM/: sram.c
    ../../HARDWARE/TIMER/: timer.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_crc.c stm32f4xx_fsmc.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_spi.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group LCD_Driver
    ../../User/bsp_stm32f4xx/src/: bsp_tft_lcd.c LCD_RA8875.c bsp_ra8875_port.c
  group DSP_Lib
    ../../DSP_LIB/: arm_cortexM4lf_math.lib
